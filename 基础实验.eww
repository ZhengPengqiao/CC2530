<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AD&#x91C7;&#x96C6;cc2530&#x6e29;&#x5eA6;&#x4e32;&#x53e3;&#x663e;&#x793A;\AD&#x91C7;&#x96C6;cc2530&#x6e29;&#x5eA6;&#x4e32;&#x53e3;&#x663e;&#x793A;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DHT11&#x6e29;&#x6e7F;&#x5eA6;&#x4F20;&#x611F;&#x5668;\DHT11&#x6e29;&#x6e7F;&#x5eA6;&#x4F20;&#x611F;&#x5668;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DS18B20&#x6e29;&#x5eA6;&#x5B9e;&#x9A8C;\DS18B20&#x6e29;&#x5eA6;&#x5B9e;&#x9A8C;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x95eA;&#x70C1;&#x706F;\LED.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\OLED&#x5B9e;&#x9A8C;\OLED&#x5B9e;&#x9A8C;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x6309;&#x952e;&#x6D41;&#x6C34;&#x706F;\&#x6309;&#x952e;&#x6D41;&#x6C34;&#x706F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x4e32;&#x53e3;&#x901A;&#x4Fe1;-&#x4e32;&#x53e3;&#x63A7;&#x5236;LED&#x706F;\&#x4e32;&#x53e3;&#x901A;&#x4Fe1;-&#x4e32;&#x53e3;&#x63A7;&#x5236;LED&#x706F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x4e32;&#x53e3;&#x901A;&#x4Fe1;-&#x53D1;&#x9001;&#x5B57;&#x7B26;&#x4e32;\&#x4e32;&#x53e3;&#x901A;&#x4Fe1;-&#x53D1;&#x9001;&#x5B57;&#x7B26;&#x4e32;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x4e32;&#x53e3;&#x901A;&#x4Fe1;-&#x63A5;&#x53D1;&#x5B57;&#x7B26;&#x4e32;&#x4e2D;&#x65AD;&#x65B9;&#x5F0F;\&#x4e32;&#x53e3;&#x901A;&#x4Fe1;-&#x63A5;&#x53D1;&#x5B57;&#x7B26;&#x4e32;&#x4e2D;&#x65AD;&#x65B9;&#x5F0F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x5B9A;&#x65F6;&#x5668;1PWM&#x5B9e;&#x9A8C;\&#x5B9A;&#x65F6;&#x5668;1PWM&#x5B9e;&#x9A8C;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x5B9A;&#x65F6;&#x5668;T1&#x67e5;&#x8Be2;&#x65B9;&#x5F0F;\&#x5B9A;&#x65F6;&#x5668;T1&#x67e5;&#x8Be2;&#x65B9;&#x5F0F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x5B9A;&#x65F6;&#x5668;T3&#x4e2D;&#x65AD;&#x65B9;&#x5F0F;\&#x5B9A;&#x65F6;&#x5668;T3&#x4e2D;&#x65AD;&#x65B9;&#x5F0F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x7ee7;&#x7535;&#x5668;&#x6A21;&#x5757;\&#x7ee7;&#x7535;&#x5668;&#x6A21;&#x5757;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x770B;&#x95e8;&#x72D7;\&#x770B;&#x95e8;&#x72D7;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x770B;&#x95e8;&#x72D7;&#x7528;&#x4F5C;&#x5B9A;&#x65F6;&#x5668;\&#x770B;&#x95e8;&#x72D7;&#x7528;&#x4F5C;&#x5B9A;&#x65F6;&#x5668;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x6D41;&#x6C34;&#x706F;\&#x6D41;&#x6C34;&#x706F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x6A21;&#x62DF;PWM&#x8C03;&#x5149;&#x5B9e;&#x9A8C;\&#x6A21;&#x62DF;PWM&#x8C03;&#x5149;&#x5B9e;&#x9A8C;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x6572;&#x51FB;&#x4F20;&#x611F;&#x5668;&#x6A21;&#x5757;\&#x6572;&#x51FB;&#x4F20;&#x611F;&#x5668;&#x6A21;&#x5757;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x4eBA;&#x4F53;&#x7eA2;&#x5916;&#x4F20;&#x611F;&#x5668;\&#x4eBA;&#x4F53;&#x7eA2;&#x5916;&#x4F20;&#x611F;&#x5668;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x5916;&#x90e8;&#x4e2D;&#x65AD;\&#x5916;&#x90e8;&#x4e2D;&#x65AD;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x5916;&#x90e8;&#x4e2D;&#x65AD;&#x6D41;&#x6C34;&#x706F;\&#x5916;&#x90e8;&#x4e2D;&#x65AD;&#x6D41;&#x6C34;&#x706F;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x7CFB;&#x7eDF;&#x7761;&#x7720;&#x5524;&#x9192;-&#x5B9A;&#x65F6;&#x5668;&#x5524;&#x9192;\&#x7CFB;&#x7eDF;&#x7761;&#x7720;&#x5524;&#x9192;-&#x5B9A;&#x65F6;&#x5668;&#x5524;&#x9192;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x7CFB;&#x7eDF;&#x7761;&#x7720;&#x5524;&#x9192;-&#x4e2D;&#x65AD;&#x5524;&#x9192;\&#x7CFB;&#x7eDF;&#x7761;&#x7720;&#x5524;&#x9192;-&#x4e2D;&#x65AD;&#x5524;&#x9192;.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\&#x906e;&#x5149;&#x6A21;&#x5757;\&#x906e;&#x5149;&#x6A21;&#x5757;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


