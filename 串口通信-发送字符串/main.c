/*****************************************************************************
*  项目名称  ： 串口通信-发送字符串
*    作者    ： 郑朋桥
*    时间    ： 2106/08/04
******************************************************************************/

/*****************************************************************************
*  添加头文件
******************************************************************************/

#include <ioCC2530.h>
#include <string.h>
#include "CHECKUART.h"

/*****************************************************************************
*函数含义：不精确延迟函数
*函数参数：延迟毫秒数
*  返回值：无返回值
*****************************************************************************/
void delayMS(int ms)
{
  int i,j;
  for(i = 0; i < ms; i++)
  {
    for(j = 0; j < 535; j++);
  }
}

void main()
{
  char ch[5];
  int count;
  setSystemCLK();
  initUart();
  
  while(1)
  {
    sentString("ab",2);
    count = readString(ch,5);
    sentString(ch,count);
    delayMS(1000);
  }
}

